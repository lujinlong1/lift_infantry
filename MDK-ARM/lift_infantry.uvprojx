# Keil uVision project lift_infantry.uvprojx, settings and files
target lift_infantry (6210000::V6.21::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lift_infantry +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Application/Inc;../Bsp/Inc;../Services/Can/Inc;../Services/AutoAim/Inc;../Devices/DjiMotor/Inc;../Config/Inc;../Devices/RobotMotors/Inc;../Diagnostics/MotorTest/Inc;../Diagnostics/Telemetry/Inc;../Diagnostics/RuntimeMonitor/Inc;../Algorithms/Pid/Inc;../Application/Chassis/Inc;../Application/Shooter/Inc;../Application/Gimbal/Inc;../Application/Lift/Inc;../Services/Remote/Inc;../Application/Remote/Inc;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  asm include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Application\Inc;..\Bsp\Inc;..\Services\Can\Inc;..\Devices\DjiMotor\Inc;..\Config\Inc;..\Devices\RobotMotors\Inc;..\Diagnostics\MotorTest\Inc;..\Diagnostics\RuntimeMonitor\Inc;..\Algorithms\Pid\Inc;..\Application\Chassis\Inc;..\Application\Shooter\Inc;..\Application\Gimbal\Inc;..\Application\Lift\Inc;..\Services\Remote\Inc;..\Application\Remote\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\Config\lift_infantry.sct
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c freertos.c can.c dma.c i2c.c spi.c tim.c usart.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group BSP
    ../Bsp/Src/: bsp_can.c
    ../Bsp/Inc/: bsp_can.h
  group Application
    ../Application/Src/: system_init.c system_task.c app_tasks.c
    ../Application/Inc/: system_init.h system_task.h app_tasks.h
  group Services
    ../Services/Can/Src/: can_rx_service.c can_dispatch.c can_tx_service.c
    ../Services/Can/Inc/: can_rx_service.h can_tx_service.h
  group Devices/DjiMotor
    ../Devices/DjiMotor/Src/: dji_motor.c
    ../Devices/DjiMotor/Inc/: dji_motor.h
  group Devices/RobotMotors
    ../Devices/RobotMotors/Src/: robot_motors.c robot_motor_commands.c
    ../Devices/RobotMotors/Inc/: robot_motors.h robot_motor_commands.h
  group Config
    ../Config/Inc/: robot_motor_config.h
  group Diagnostics/MotorTest
    ../Diagnostics/MotorTest/Src/: friction_test_task.c pitch_test_task.c lift_jog_task.c
    ../Diagnostics/MotorTest/Inc/: friction_test_task.h pitch_test_task.h lift_jog_task.h
  group Algorithms/Pid
    ../Algorithms/Pid/Src/: pid.c
    ../Algorithms/Pid/Inc/: pid.h
  group Application/Chassis
    ../Application/Chassis/Src/: chassis_control.c chassis_spin.c
    ../Application/Chassis/Inc/: chassis_control.h chassis_spin.h
  group Application/Shooter
    ../Application/Shooter/Src/: friction_control.c feed_control.c shooter_control.c
    ../Application/Shooter/Inc/: friction_control.h feed_control.h shooter_control.h
  group Application/Gimbal
    ../Application/Gimbal/Src/: yaw_control.c pitch_control.c
    ../Application/Gimbal/Inc/: yaw_control.h pitch_control.h
  group Application/Lift
    ../Application/Lift/Src/: lift_top.c lift_diagnostics.c lift_control.c lift_sync.c lift_guard.c lift_homing.c lift_seq.c lift_geometry.c lift_control_task.c lift_kinematics.c lift_safety.c
    ../Application/Lift/Inc/: lift_top.h lift_control.h lift_sync.h lift_guard.h lift_homing.h lift_seq.h lift_geometry.h lift_control_task.h lift_kinematics.h lift_safety.h
  group Services/Remote
    ../Services/Remote/Src/: dbus_remote.c
    ../Services/Remote/Inc/: dbus_remote.h
  group Application/Remote
    ../Application/Remote/Src/: remote_control_task.c remote_lift.c
    ../Application/Remote/Inc/: remote_control_task.h remote_lift.h
  group Diagnostics/Telemetry
    ../Diagnostics/Telemetry/Src/: telemetry_task.c
    ../Diagnostics/Telemetry/Inc/: telemetry_task.h
  group Services/AutoAim
    ../Services/AutoAim/Src/: auto_aim_link.c
    ../Services/AutoAim/Inc/: auto_aim_link.h
  group Diagnostics/RuntimeMonitor
    ../Diagnostics/RuntimeMonitor/Src/: runtime_monitor.c
    ../Diagnostics/RuntimeMonitor/Inc/: runtime_monitor.h
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 5.6.0
